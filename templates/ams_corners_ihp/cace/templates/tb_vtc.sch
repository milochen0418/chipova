** sch_path: templates/ams_corners_ihp/cace/templates/tb_vtc.sch
**.subckt tb_vtc
Vdd VDD GND CACE{vdd}
Vin IN GND 0
x1 IN OUT VDD GND inverter
**** begin user architecture code


* PDK models at the process corner, the circuit's netlist, the temperature
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.include CACE{DUT_path}
.temp CACE{temperature}

.control
set num_threads=1
dc Vin 0 CACE{vdd} 1m
* switching threshold: the input voltage where vout = vin
let diff = v(out) - v(in)
meas dc vm when diff=0 fall=1
* noise margins from the unity-gain points (dVout/dVin = -1)
let slope = deriv(v(out))
meas dc vil when slope=-1 fall=1
meas dc vih when slope=-1 rise=1
meas dc voh find v(out) when slope=-1 fall=1
meas dc vol find v(out) when slope=-1 rise=1
let nml = vil - vol
let nmh = voh - vih
echo $&vm $&nml $&nmh > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  inverter.sym # of pins=4
** sym_path: templates/ams_corners_ihp/xschem/inverter.sym
** sch_path: templates/ams_corners_ihp/xschem/inverter.sch
.subckt inverter IN OUT VDD VSS
*.ipin IN
*.opin OUT
*.iopin VDD
*.iopin VSS
XM1 OUT IN VDD VDD sg13_lv_pmos w=2u l=0.13u ng=1 m=1 mm_ok=1
XM2 OUT IN VSS VSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
