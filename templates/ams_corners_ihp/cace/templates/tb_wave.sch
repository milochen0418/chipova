** sch_path: templates/ams_corners_ihp/cace/templates/tb_wave.sch
**.subckt tb_wave
Vdd VDD GND CACE{vdd}
Vin IN GND pulse(0 CACE{vdd} 200p CACE{tslew} CACE{tslew} 1.8n 4n)
x1 IN OUT VDD GND inverter
CL OUT GND CACE{cload} m=1
**** begin user architecture code


* PDK models at the process corner, the circuit's netlist, the temperature
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/models/cornerMOSlv.lib mos_CACE{corner}
.include CACE{DUT_path}
.temp CACE{temperature}

.control
set num_threads=1
set wr_singlescale
tran 2p 4n
let t_ns = time * 1e9
* columns: time (s), t_ns, vin, vout
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data t_ns v(in) v(out)
.endc


**** end user architecture code
**.ends

* expanding   symbol:  inverter.sym # of pins=4
** sym_path: templates/ams_corners_ihp/xschem/inverter.sym
** sch_path: templates/ams_corners_ihp/xschem/inverter.sch
.subckt inverter IN OUT VDD VSS
*.ipin IN
*.opin OUT
*.iopin VDD
*.iopin VSS
XM1 OUT IN VDD VDD sg13_lv_pmos w=2u l=0.13u ng=1 m=1 mm_ok=1
XM2 OUT IN VSS VSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
