** sch_path: templates/ams_corners_sky130/cace/templates/tb_delay.sch
**.subckt tb_delay
Vdd VDD GND CACE{vdd}
Vin IN GND pulse(0 CACE{vdd} 200p CACE{tslew} CACE{tslew} 1.8n 4n)
x1 IN OUT VDD GND inverter
CL OUT GND CACE{cload} m=1
**** begin user architecture code


* PDK models at the process corner, the circuit's netlist, the temperature
.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}
.include CACE{DUT_path}
.temp CACE{temperature}

.control
set num_threads=1
tran 1p 4n
meas tran tpd_hl trig v(in) val=CACE[CACE{vdd}/2] rise=1 targ v(out) val=CACE[CACE{vdd}/2] fall=1
meas tran tpd_lh trig v(in) val=CACE[CACE{vdd}/2] fall=1 targ v(out) val=CACE[CACE{vdd}/2] rise=1
echo $&tpd_hl $&tpd_lh > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  inverter.sym # of pins=4
** sym_path: templates/ams_corners_ihp/xschem/inverter.sym
** sch_path: templates/ams_corners_ihp/xschem/inverter.sch
.subckt inverter IN OUT VDD VSS
*.ipin IN
*.opin OUT
*.iopin VDD
*.iopin VSS
XM1 OUT IN VDD VDD sg13_lv_pmos w=2u l=0.13u ng=1 m=1 mm_ok=1
XM2 OUT IN VSS VSS sg13_lv_nmos w=1u l=0.13u ng=1 m=1 mm_ok=1
.ends

.GLOBAL GND
.end
